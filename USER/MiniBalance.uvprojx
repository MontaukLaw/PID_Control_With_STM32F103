# Keil uVision project MiniBalance.uvprojx, settings and files
target MiniBalance (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniBalance +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\MiniBalance_COER;..\STM32F10x_FWLib\inc;..\MiniBalance_HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MiniBalance_HARDWARE\ENCODER;..\MiniBalance_HARDWARE\TIMER;..\MiniBalance_HARDWARE\CONTROL;..\MiniBalance_HARDWARE\DP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c MiniBalance.c
  group CORE
    ../MiniBalance_COER/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../MiniBalance_HARDWARE/TIMER/: timer.c
    ../MiniBalance_HARDWARE/ENCODER/: encoder.c
    ../MiniBalance_HARDWARE/CONTROL/: control.c
    ../MiniBalance_HARDWARE/DP/: DataScope_DP.c
